# Keil uVision project Ultrasonic_Proximity.uvproj, settings and files
target Ultrasonic_Proximity (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: Ultrasonic_Proximity +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
